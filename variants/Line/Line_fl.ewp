# IAR project Line_fl.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD20E18 Atmel ATSAMD20E18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: F_CPU=48000000L; ARDUINO=10805; ARDUINO_SAMD_ZERO; ARDUINO_ARCH_SAMD; CLOCKCONFIG_INTERNAL; BOARD_ID_Line; USB_DISABLED; NO_UART; NO_WIRE; NO_SPI; __8KB_BOOTLOADER__; __SAMD20E18__
  ICCARM.CCDiagSuppress: pa050
  ICCARM.CCIncludePath2: C:\Users\M43507\Documents\Arduino\libraries\ZPID; C:\Users\M43507\Documents\Arduino\libraries\Ultrasonic\src; C:\Users\M43507\Documents\Arduino\libraries\TM1637; C:\Users\M43507\Documents\Arduino\libraries\WireUtility; C:\Users\M43507\Documents\Arduino\libraries\ZPCA9685; C:\Users\M43507\Documents\Arduino\libraries\ZMCP23017; C:\Users\M43507\Documents\Arduino\libraries\Adafruit-MCP23017-Arduino-Library; C:\Users\M43507\Documents\Arduino\libraries\Zmotor2; C:\Users\M43507\Documents\Arduino\libraries\Zmotor3; C:\Users\M43507\Documents\Arduino\libraries\ZCmdMotor; C:\Users\M43507\Documents\Arduino\libraries\ZEncoder; ../../../../../hardware/samd/src/libraries/SPI/; ../../../../../hardware/samd/src/libraries/Wire/; ../../../../../tools/CMSIS-Atmel/src/CMSIS/Device/ATMEL/; ../../../../../hardware/samd/src/; ../../../../../../arduino/tools/CMSIS/4.5.0/CMSIS/Include/; ../../../../../../arduino/tools/CMSIS-Atmel/1.1.0/CMSIS/Device/ATMEL/; ../../../../../../zoubworld_Arduino/hardware/samd/src/cores/arduino/; ../../../../../../zoubworld_Arduino/hardware/samd/src/variants/Line/; ../../../../../../zoubworld_Arduino/hardware/samd/1.6.33/cores/arduino/; ../../../../../../zoubworld_Arduino/hardware/samd/1.6.33/variants/Line/
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 2
  AARM.ADefines: __GAMBIT__; __SAMC21G18A__; DEVICE_PRJ_NUMBER=U3008; NO_FORCE_OSC0_STARTUP; DESIGN_REV=revC; SOFTBUILD_STARTUP_NVMWS=3; SOFTBUILD_STARTUP_NVM_AUTO_WRITE; DUT_VERSION=1; ARM_CM0P=1; COREFAMILY=ARM_CM0P; NO_FORCE_OSC0_STARTUP=1; SOFTBUILD_DISABLE_PAC=1; SOFTBUILD_STARTUP_DISABLEPICACHU=1; SOFTBUILD_STARTUP_HMATRIX_FAST=1; I8800=8800; I8801=8801; I8802=8802; I8803=8803; U3002=3002; U3003=3003; U3001=3001; U3004=3004; U3003_revD=0x3003D; U3005=3005; U3006=3006; U3007=3007; U3008=3008; U3009=3009; U3010=3010; U3011=3011; U3012=3012; U3013=3013; U3014=3014; U3016=3016; U3019=3019; U3401=3401; U3020=3020; __LINKER_FLASH__; DEBUG_LEVEL=0; STACK_POINTER_DIV=5; __GAMBIT__; __SAMC21G18A__; DEVICE_PRJ_NUMBER=U3008; NO_FORCE_OSC0_STARTUP; DESIGN_REV=revC; SOFTBUILD_STARTUP_NVMWS=3; SOFTBUILD_STARTUP_NVM_AUTO_WRITE; DUT_VERSION=1; ARM_CM0P=1; __GAMBIT__; __SAMC21G18A__; DEVICE_PRJ_NUMBER=U3008; NO_FORCE_OSC0_STARTUP; DESIGN_REV=revC; SOFTBUILD_STARTUP_NVMWS=3; SOFTBUILD_STARTUP_NVM_AUTO_WRITE; DUT_VERSION=1; ARM_CM0P=1; __GAMBIT__; __SAMC21G18A__; DEVICE_PRJ_NUMBER=U3008; NO_FORCE_OSC0_STARTUP; DESIGN_REV=revC; SOFTBUILD_STARTUP_NVMWS=3; SOFTBUILD_STARTUP_NVM_AUTO_WRITE; DUT_VERSION=1; ARM_CM0P=1; PVP_REPORT=" ./_noregtest/_noregtest_adc_test_fl.rs232 "; PVP_BENCH=" adc_test_fl.hex "; CPU_F=10000000; STACK_POINTER_DIV=5; __AVR32_ABI_COMPILER__=1
  AARM.AUserIncludes: ..\..\dsg\U3008\verification\import\CM4\include; ..\..\dsg\U3008\verification\libtest; ..\..\dsg\U3008\verification\startup\iar; ..\..\dsg\; ..\..\dsg\U3008; ..\..\dsg\U3008\verification\headers; ..\..\dsg\U3008\verification\libtest\; ..\..\dsg\U3008\verification\import\ac_U2245\libtest; ..\..\dsg\U3008\verification\import\adc_U2247\libtest; ..\..\dsg\U3008\verification\import\atw_U2219\libtest; ..\..\dsg\U3008\verification\import\can_U2259\libtest; ..\..\dsg\U3008\verification\import\ccl_U2225\libtest; ..\..\dsg\U3008\verification\import\cfd_U2123\libtest; ..\..\dsg\U3008\verification\import\cm0p_U2001\libtest; ..\..\dsg\U3008\verification\import\dac_U2214\libtest; ..\..\dsg\U3008\verification\import\divas_U2258\libtest; ..\..\dsg\U3008\verification\import\dmac_U2223\libtest; ..\..\dsg\U3008\verification\import\dsu_U2209\libtest; ..\..\dsg\U3008\verification\import\eic_U2254\libtest; ..\..\dsg\U3008\verification\import\evsys_U2256\libtest; ..\..\dsg\U3008\verification\import\fdpll_U2118\libtest; ..\..\dsg\U3008\verification\import\freqm_U2257\libtest; ..\..\dsg\U3008\verification\import\gclk_U2122\libtest; ..\..\dsg\U3008\verification\import\mclk_U2234\libtest; ..\..\dsg\U3008\verification\import\mtb_U2002\libtest; ..\..\dsg\U3008\verification\import\nvmctrl_U2207\libtest; ..\..\dsg\U3008\verification\import\osc32kctrl_U2246\libtest; ..\..\dsg\U3008\verification\import\osc48m_U2124\libtest; ..\..\dsg\U3008\verification\import\oscctrl_U2119\libtest; ..\..\dsg\U3008\verification\import\pac_U2120\libtest; ..\..\dsg\U3008\verification\import\picachu_U2218\libtest; ..\..\dsg\U3008\verification\import\pm_U2240\libtest; ..\..\dsg\U3008\verification\import\port_U2210\libtest; ..\..\dsg\U3008\verification\import\ptc_U2215\libtest; ..\..\dsg\U3008\verification\import\rstc_U2239\libtest; ..\..\dsg\U3008\verification\import\rtc_U2250\libtest; ..\..\dsg\U3008\verification\import\sdadc_U2260\libtest; ..\..\dsg\U3008\verification\import\sercom_U2201\libtest; ..\..\dsg\U3008\verification\import\supc_U2117\libtest; ..\..\dsg\U3008\verification\import\tal_U2253\libtest; ..\..\dsg\U3008\verification\import\tcc_U2213\libtest; ..\..\dsg\U3008\verification\import\tc_U2249\libtest; ..\..\dsg\U3008\verification\import\tsens_U2261\libtest; ..\..\dsg\U3008\verification\import\wdt_U2251\libtest; ..\..\dsg\U3008\verification\import\xosc_U2105\libtest; .\; ..\..\; ..\..\..\661P1H_dev; ..\..\device\; ..\..\test_func\; ..\..\library\; ..\..\blocks\; ..\..\drivers\; ..\..\dsg\U3008\verification\headers\; ..\..\avr32_devices\; ..\..\library\; ..\..\blocks\; ..\..\..\661P1H_dev\; ..\..\ASF\sam\utils\; ..\..\ASF\sam\utils\preprocessor\; ..\..\ASF\sam\drivers\intc\; ..\..\ASF\sam\drivers\pm\; ..\..\ASF\sam\drivers\scif\
  OBJCOPY.OOCOutputFile: adc_test_fl.hex
  ILINK.IlinkOutputFile: adc_test_fl.elf
  ILINK.IlinkIcfFile: linker_scripts\iar\flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 0
  ICCARM.CCDefines: as above
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ../../cores/arduino/: abi.cpp cortex_handlers.c delay.c hooks.c IPAddress.cpp main.cpp new.cpp PinExtender.cpp Print.cpp pulse.c Reset.cpp RingBuffer.cpp SERCOM.cpp startup.c Stream.cpp Tone.cpp Uart.cpp WInterrupts.c wiring.c wiring_analog.c wiring_digital.c wiring_private.c wiring_shift.c WMath.cpp WString.cpp
    ../: ino.cpp
    ../../../../../../../../../../Documents/Arduino/libraries/PID/: PID_v1.cpp
    ../../libraries/SPI/: SPI.cpp
    ../../../../../../../../../../Documents/Arduino/libraries/TM1637/: TM1637Display.cpp
    ./: variant.cpp
    ../../libraries/Wire/: Wire.cpp
